# Keil uVision project New_Chassis.uvprojx, settings and files
target New_Chassis (6210000::V6.21::ARMCLANG)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: New_Chassis +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F405xx,DOG_LEG_USE_CPP_MAIN
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../RM2023_Lib_V1.2;../Motor_Lib;../Math_Lib;../IMU;../CH010;../Control_Lib;../App_Lib
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f405xx.s
  group Application/User/Core
    ../RM2023_Lib_V1.2/: CP_System.c RM_Lib.cpp
    ../Core/Src/: main.c gpio.c can.c dma.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_can.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Motor_Lib
    ../Motor_Lib/: DM.cpp DM.h
  group Math_Lib
    ../Math_Lib/: SMC.cpp SMC.h
  group IMU_Lib
    ../IMU/: imu_data_decode.c imu_data_decode.h packet.c packet.h
    ../CH010/: example_data.c example_data.h hipnuc_dec.c hipnuc_dec.h nmea_dec.c nmea_dec.h
  group Control_Lib
    ../Control_Lib/: leg.cpp leg.h leg_internal.h leg_balance.cpp leg_output.cpp leg_height.cpp
  group App_Lib
    ../App_Lib/: app_chassis.cpp app_chassis.h main.cpp
software components: CMSIS:CORE 5.6.0
